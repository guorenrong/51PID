# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F086B tenx
  cpu: IRAM(0-0xFF) CLOCK(18000000) XRAM(0xFF00-0xFFFF)
  output: main +hex
  AfterMake: .\_MakeTenx_main\run.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: FRE_2_DIV
  c include: ..\..\..\Drivers
  group Source Group 1
    ./: STARTUP_TENX52.A51
    ./src/: main.c TM52F086B_bsp.c
